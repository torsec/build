## br-ext/package/rust_keylime_ext/Config.in
```kconfig
config BR2_PACKAGE_RUST_KEYLIME_EXT
	bool "rust_keylime"
	help
	  https://github.com/keylime/rust-keylime
```
